# Keil uVision project RTLSDR_STM32F407VET6_USB_01.uvprojx, settings and files
target RTLSDR_STM32F407VET6_USB_01 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RTLSDR_STM32F407VET6_USB_01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ILI9341;../XPT2046;..\Middlewares\ST\STM32_USB_Host_Library\Class\RTLSDR\Src;..\Middlewares\ST\STM32_USB_Host_Library\Class\RTLSDR\Inc;..\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c usb_host.c usbh_conf.c stm32f4xx_it.c stm32f4xx_hal_msp.c libusb_port.c usb_user_process.c
    ../Inc/: libusb.h libusb_port.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group RTLSDR
    ../Middlewares/ST/STM32_USB_Host_Library/Class/RTLSDR/Src/: usbh_rtlsdr.c librtlsdr.c tuner_fc0012.c tuner_fc0013.c tuner_fc2580.c tuner_r82xx.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/RTLSDR/Inc/: reg_field.h tuner_fc0012.h tuner_fc0013.h tuner_fc2580.h tuner_r82xx.h usbh_rtlsdr.h reg_field_.h rtl-sdr.h rtl-sdr_export.h rtlsdr_i2c.h
  group ILI9341
    ../ILI9341/: colors.h font8.c font12.c font16.c font20.c font24.c fonts.h ili9341.c ili9341.h image.h registers.h
  group XPT2046
    ../XPT2046/: XPT2046_touch.c XPT2046_touch.h
  group Log
    ../Log/: lcd_log.c
software components: CMSIS:CORE 4.3.0
